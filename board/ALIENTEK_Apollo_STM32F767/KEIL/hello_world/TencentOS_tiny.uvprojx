# Keil uVision project TencentOS_tiny.uvprojx, settings and files
target TencentOS_tiny (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F767IGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.12.0
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: TencentOS_tiny +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F767xx
  c include: ..\..\BSP\Inc;..\..\..\..\platform\vendor_bsp\st\STM32F7xx_HAL_Driver\Inc;..\..\..\..\platform\vendor_bsp\st\STM32F7xx_HAL_Driver\Inc\Legacy;..\..\..\..\platform\vendor_bsp\st\CMSIS\Device\ST\STM32F7xx\Include;..\..\..\..\platform\vendor_bsp\st\CMSIS\Include;..\..\..\..\kernel\core\include;..\..\..\..\kernel\pm\include;..\..\..\..\arch\arm\arm-v7m\common\include;..\..\..\..\arch\arm\arm-v7m\cortex-m7\armcc;..\..\TOS-CONFIG;..\..\..\..\osal\cmsis_os
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32f767xx.s
  group Application/User
    ../../BSP/Src/: gpio.c main.c mcu_init.c stm32f7xx_hal_msp.c stm32f7xx_it.c usart.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../platform/vendor_bsp/st/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c
  group Drivers/CMSIS
    ../../BSP/Src/: system_stm32f7xx.c
  group kernel
    ../../../../kernel/core/: tos_event.c tos_global.c tos_mmblk.c tos_mmheap.c tos_mutex.c tos_pend.c tos_robin.c tos_sched.c tos_sem.c tos_sys.c tos_task.c tos_tick.c tos_time.c tos_timer.c tos_binary_heap.c tos_char_fifo.c tos_completion.c tos_countdownlatch.c tos_mail_queue.c tos_message_queue.c tos_priority_mail_queue.c tos_priority_message_queue.c tos_priority_queue.c tos_ring_queue.c
    ../../../../kernel/pm/: tos_pm.c tos_tickless.c
  group cpu
    ../../../../arch/arm/arm-v7m/cortex-m7/armcc/: port_c.c port_s.S
    ../../../../arch/arm/arm-v7m/common/: tos_cpu.c tos_fault.c
  group cmsis
    ../../../../osal/cmsis_os/: cmsis_os.c
  group config
    ../../TOS-CONFIG/: tos_config.h
  group examples
    ../../../../examples/hello_world/: hello_world.c
  group tickless_bsp
    ../../BSP/Src/tickless/: bsp_pwr_mgr.c bsp_pm_device.c bsp_tickless_alarm.c
software components: CMSIS:CORE 4.3.0
