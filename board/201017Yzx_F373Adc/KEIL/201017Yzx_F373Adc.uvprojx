# Keil uVision project 201017Yzx_F373Adc.uvprojx, settings and files
target F373Adc (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F373RCTx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x803FFFF) CLOCK(72000000) FPU2 CPUTYPE("Cortex-M4")
  output: F373Adc +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F373xC
  c include: ../Core/Inc;..\BSP\Inc;../../../platform/vendor_bsp/st/STM32F3xx_HAL_Driver/Inc;../../../platform/vendor_bsp/st/STM32F3xx_HAL_Driver/Inc/Legacy;../../../platform/vendor_bsp/st/CMSIS/Device/ST/STM32F3xx/Include;../../../platform/vendor_bsp/st/CMSIS/Include;..\..\..\kernel\core\include;..\..\..\kernel\pm\include;..\..\..\arch\arm\arm-v7m\common\include;..\..\..\arch\arm\arm-v7m\cortex-m4\armcc;..\TOS-CONFIG;..\..\..\osal\cmsis_os
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32f373xc.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f3xx_it.c stm32f3xx_hal_msp.c
  group Application/BSP
    ../BSP/src/: mcu_init.c
  group Drivers/STM32F3xx_HAL_Driver
    ../../../platform/vendor_bsp/st/STM32F3xx_HAL_Driver/Src/: stm32f3xx_ll_usb.c stm32f3xx_hal_adc.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_dma.c stm32f3xx_hal_cortex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_exti.c stm32f3xx_hal_can.c stm32f3xx_hal_dac.c stm32f3xx_hal_dac_ex.c stm32f3xx_hal_iwdg.c stm32f3xx_hal_rtc.c stm32f3xx_hal_rtc_ex.c stm32f3xx_hal_sdadc.c stm32f3xx_hal_spi.c stm32f3xx_hal_spi_ex.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal_pcd.c stm32f3xx_hal_pcd_ex.c
  group kernel
    ../../../kernel/core/: tos_event.c tos_global.c tos_mmblk.c tos_mmheap.c tos_mutex.c tos_pend.c tos_robin.c tos_sched.c tos_sem.c tos_sys.c tos_task.c tos_tick.c tos_time.c tos_timer.c tos_binary_heap.c tos_char_fifo.c tos_completion.c tos_countdownlatch.c tos_mail_queue.c tos_message_queue.c tos_priority_mail_queue.c tos_priority_message_queue.c tos_priority_queue.c tos_ring_queue.c
    ../../../kernel/pm/: tos_pm.c tos_tickless.c
  group cpu
    ../../../arch/arm/arm-v7m/cortex-m4/armcc/: port_c.c port_s.S
    ../../../arch/arm/arm-v7m/common/: tos_cpu.c tos_fault.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f3xx.c
  group cmsis
    ../../../osal/cmsis_os/: cmsis_os.c
  group config
    ../TOS-CONFIG/: tos_config.h
  group examples
    ../../../examples/hello_world/: hello_world.c
  group tickless_bsp
    ../BSP/Src/tickless/: bsp_pwr_mgr.c bsp_pm_device.c bsp_tickless_alarm.c
software components: CMSIS:CORE 4.3.0
